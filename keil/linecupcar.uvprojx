# Keil uVision project linecupcar.uvprojx, settings and files
target Target 1 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: linecupcar
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group inc
    ../inc/: ftm_driver.h linescan_driver.h adc_driver.h camera_driver.h pit_driver.h uart.h main.h
  group src
    ../src/: isr.c adc_driver.c test.c main.c pit_driver.c ftm_driver.c uart.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
